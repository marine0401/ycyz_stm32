# Keil uVision project demo stand.uvprojx, settings and files
target demo stand (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: demo stand +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c include: ../Core/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc;../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L4xx/Include;../Drivers/CMSIS/Include;..\BSP;..\SYSTEM;..\BSP\sensor;..\COMM;..\example;..\COMM\nbiot;..\example\nbiot_aliyun_air;..\BSP\GUI;..\BSP\sensor;..\BSP\hard_change;..\BSP\sensor\CCS811
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c dma.c spi.c tim.c usart.c stm32l4xx_it.c stm32l4xx_hal_msp.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc.c stm32l4xx_hal_adc_ex.c stm32l4xx_hal.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_cortex.c stm32l4xx_hal_exti.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group BSP
    ../BSP/lcd_1_3/: tftlcd.c
    ../BSP/GUI/: gui.c
    ../BSP/sensor/power/: power.c
    ../BSP/hard_change/: bsp_change.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
  group SENSOR
    ../BSP/sensor/: sensor_config.h sensor.c
    ../BSP/sensor/smoke/: smoke.c
    ../BSP/sensor/CCS811/: CCS811.c myiic.c
  group COMM
    ../COMM/: serial_port.c comm_config.h
    ../COMM/nbiot/: nbiot.c
  group EXAMPLE
    ../example/: task_config.h
    ../example/nbiot_aliyun_air/: example_nbiot_aliyun_air.c
  group Lib
    ../LIB/: at.lib
software components: CMSIS:CORE 5.2.0
